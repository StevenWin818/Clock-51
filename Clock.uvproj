# Keil uVision project Clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: clock.h font.h key.h lcd_ks0108.h stopwatch.h buzzer.c clock.c display.c font.c key.c lcd_ks0108.c main.c stopwatch.c buzzer.h display.h
